## sample/sample.yaml
```yaml
common:
  filter: TOOLCHAIN_HAS_NEWLIB == 1
sample:
  name: RTC shutdown tracking module sample
```
